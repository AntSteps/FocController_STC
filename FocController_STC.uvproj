# Keil uVision project FocController_STC.uvproj, settings and files
target FocController_STC (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: FocController_STC +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group User Sources
    ./Sources/: crc6.c crc8.c uart_controller.c encoder.c svpwm.c calibration.c motor.c
  group AiCube
    ./Sources/: main.c port.c clock.c timer.c uart.c adc.c spi.c pwm.c mathlib.c
    ./Sources/lib/: ai8051u_32_mdu32.lib ai8051u_32_tfpu.lib
